# Keil uVision project STM32KeilPrj.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32KeilPrj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\App\Main;..\App\LED;..\App\DataType;..\HW\RCC;..\HW\Timer;..\HW\UART1;..\FW\inc;..\ARM\NVIC;..\ARM\SysTick;..\ARM\System;..\HW\Encoder;..\HW\PWM;..\HW\MPU6050;..\HW\Exti;..\App\Motor;..\Alg;..\HW\delay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../App/Main/: Main.c
    ../App/LED/: LED.c
    ../App/Motor/: Motor.c
  group Alg
    ../Alg/: PID.c
  group HW
    ../HW/RCC/: RCC.c
    ../HW/Timer/: Timer.c
    ../HW/UART1/: Queue.c UART1.c
    ../HW/Encoder/: Encoder.c
    ../HW/PWM/: PWM.c
    ../HW/MPU6050/: inv_mpu_dmp_motion_driver.c mpu6050.c mpuiic.c inv_mpu.c
    ../HW/Exti/: Exti.c
  group FW
    ../FW/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_exti.c
  group ARM
    ../ARM/System/: stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s core_cm3.c
    ../ARM/NVIC/: NVIC.c
    ../ARM/SysTick/: SysTick.c
